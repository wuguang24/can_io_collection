# IAR project Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; SERVER; IAP_MODE_SYS
  ICCARM.CCDiagSuppress: Pe236
  ICCARM.CCIncludePath2: ..\inc; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_ETH_Driver\inc; ..\..\Libraries\CMSIS\Core\CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exp_io_ctrl_slave_v5_0_1_12_260426.bin
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group ETHLib
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group FWLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: aw_i2c.c can2_bus.c can_bus.c flash.c i2c.c can.c queue.c io_ctrl.c io.c pin_cfg.c port_cos.c fault_led.c station_learn.c slave_cfg_store.c lcd_uart.c main.c stm32f107.c stm32f10x_it.c
